options:
  parameters:
    author: Juan Mateo Alban Mendez
    generate_options: qt_gui
    id: BeamformingUSRPB210
    output_language: python
    title: BeamformingUSRPB210
  states: {}

blocks:
- name: Frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 600e6
    step: '1000'
    stop: 2.50e9
    value: 2.45e9
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '70'
  states: {}
- name: RF_Gain2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '20'
  states: {}
- name: phaseUSRP
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-3.2'
    step: '0.01'
    stop: '3.2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 50e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '300e-3'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '300e-3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100e-3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '100e-3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '30'
    type: complex
  states: {}
- name: blocks_null_sink_3_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, numeroAntenas=4, direccionMaximo=30.0, tipoArreglo=True, frecuencia=2.45e9, phase_correctionUSRP = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Phase Computing',   # will show up in GRC

                  
                  in_sig=[np.complex64, np.complex64],
                  out_sig=numeroAntenas*[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.numeroAntenas = numeroAntenas
              self.direccionMaximo = direccionMaximo
              self.tipoArreglo = tipoArreglo
              self.frecuencia = frecuencia
              self.phase_correctionUSRP = phase_correctionUSRP


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              c = 299792458
              longitudOnda = c/self.frecuencia 
              beta = 2*np.pi/longitudOnda
              imag = 0 + 1j

              if self.tipoArreglo:
                  d = 0.0543
                  alpha = beta*d*np.cos(self.direccionMaximo*(np.pi/180))
                  alphan = [n*alpha for n in range(1, self.numeroAntenas+1)]
                  
                  for i in range(self.numeroAntenas):
                      if i < 2:
                          output_items[i][:] = input_items[0] * (np.cos(alphan[i]) + np.sin(alphan[i])*imag)
                      else:
                          output_items[i][:] = input_items[1] * (np.cos(alphan[i]) + np.sin(alphan[i])*imag)*(np.cos(self.phase_correctionUSRP) + np.sin(self.phase_correctionUSRP)*imag)
                     
              else:
                  r = 0.06
                  theta_0 = 90
                  for n in range(self.numeroAntenas):
                      phin = ((2*np.pi)/self.numeroAntenas)*(n+1)
                      alphan = beta*r*np.sin(theta_0*(np.pi/180))*np.cos(self.direccionMaximo*(np.pi/180)-phin)
                      if n < 2:
                          output_items[n][:] = input_items[0] * (np.cos(alphan) + np.sin(alphan)*imag)
                      else:
                          output_items[n][:] = input_items[0] * (np.cos(alphan) + np.sin(alphan)*imag)*(np.cos(self.phase_correctionUSRP) + np.sin(self.phase_correctionUSRP)*imag)

              
              return len(output_items[0])
    direccionMaximo: '60.0'
    frecuencia: 2450e6
    numeroAntenas: '4'
    phase_correctionUSRP: phaseUSRP
    tipoArreglo: 'False'
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, phase_correction=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='phase_correction',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.phase_correction = phase_correction

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              imag=0+1j
              output_items[0][:] = input_items[0] * (np.cos(self.phase_correction) + np.sin(self.phase_correction)*imag)
              return len(output_items[0])
    phase_correction: '5'
  states: {}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, phase_correction=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='phase_correction',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.phase_correction = phase_correction

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              imag=0+1j
              output_items[0][:] = input_items[0] * (np.cos(self.phase_correction) + np.sin(self.phase_correction)*imag)
              return len(output_items[0])
    phase_correction: '4.83'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Synchronization',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              imag = 0 + 1j
              angleSignal1 = np.angle(input_items[0]) #computador
              angleSignal2 = np.angle(input_items[1]) #usrpreferencia
            
              angle = angleSignal1 - angleSignal2
              output_items[0][:] = input_items[0] * (np.cos(angle) - np.sin(angle)*imag)

              return len(output_items[0])
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Synchronization',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              imag = 0 + 1j
              angleSignal1 = np.angle(input_items[0]) #computador
              angleSignal2 = np.angle(input_items[1]) #usrpreferencia
            
              angle = angleSignal1 - angleSignal2
              output_items[0][:] = input_items[0] * (np.cos(angle) - np.sin(angle)*imag)

              return len(output_items[0])
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: 200e3
    bw1: 200e3
    center_freq0: 2.45e9
    center_freq1: Frequency
    clock_source0: external
    dev_addr: '"serial=30ECB92"'
    dev_args: '""'
    gain0: RF_Gain
    gain1: RF_Gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: 200e3
    bw1: 200e3
    center_freq0: 2.45e9
    center_freq1: Frequency
    clock_source0: external
    dev_addr: '"serial=30ECBB4"'
    dev_args: '""'
    gain0: RF_Gain
    gain1: RF_Gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: 200e3
    bw1: 1e3
    center_freq0: 2e9
    center_freq1: 2e9
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"serial=30ECB92"'
    dev_args: '""'
    gain0: RF_Gain2
    gain1: '20'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: 200e3
    bw1: 1e3
    center_freq0: 2e9
    center_freq1: 2e9
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"serial=30ECBB4"'
    dev_args: '""'
    gain0: RF_Gain2
    gain1: '20'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_1, '0']
- [analog_sig_source_x_0, '0', epy_block_1_1, '0']
- [blocks_add_const_vxx_0_0_0, '0', epy_block_0_0, '1']
- [blocks_add_const_vxx_0_1, '0', epy_block_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', epy_block_1, '1']
- [blocks_multiply_const_vxx_1_0, '0', epy_block_1_1, '1']
- [epy_block_0_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0_0, '1', epy_block_0_1_0_0, '0']
- [epy_block_0_0, '2', uhd_usrp_sink_0_0, '0']
- [epy_block_0_0, '3', epy_block_0_1_0, '0']
- [epy_block_0_1_0, '0', uhd_usrp_sink_0_0, '1']
- [epy_block_0_1_0_0, '0', uhd_usrp_sink_0, '1']
- [epy_block_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [epy_block_1_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [high_pass_filter_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [uhd_usrp_source_0, '0', high_pass_filter_0, '0']
- [uhd_usrp_source_0, '1', blocks_null_sink_4, '0']
- [uhd_usrp_source_0_0, '0', high_pass_filter_0_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_null_sink_3_0, '0']

metadata:
  file_format: 1
